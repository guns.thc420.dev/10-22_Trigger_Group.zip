# Autodesk Inventor part: Trigger Bushings
Saved by Autodesk Inventor 2011 (Build 150239000, 239)
## iProperties
Created: 2011-09
Part Number: Trigger Bushings
Material: UHMW, Black
Document SubType Name: Modeling
Designer: Bob Clark
Manufacturer: Standard
Standards Organization: Custom
Density: 0.94 g/cm^3
Author: Bob Clark
## Design history (mm, degrees)
sketch "Sketch1"
  geometry: C1 r 6.35 at (0, 0)
  constraints: 1 centre point
  dimensions: "d0" = 12.7 diameter of C1
extrude "Extrusion1" new body sketch "Sketch1" distance "d1" = 6.35; taper "d2" = 0 deg
sketch "Sketch2"
  geometry: C1 r 6.35 at (0, 0) reference; C2 r 3.912 at (0, 0)
  constraints: 1 centre point
  dimensions: "d3" = 7.8232 diameter of C2
extrude "Extrusion2" cut sketch "Sketch2" distance "d4" = 1.905; taper "d5" = 0 deg
sketch "Sketch3"
  geometry: C1 r 3.912 at (0, 0) reference; C2 r 1.988 at (0, 0)
  constraints: 1 centre point
  dimensions: "d6" = 3.9751 diameter of C2
extrude "Extrusion3" cut sketch "Sketch3" stored distance "d7" = 1.905; taper "d8" = 0 deg
sketch "Sketch4"
  geometry: C1 r 6.35 at (0, 0) reference; C2 r 2.743 at (0, 0)
  constraints: 1 centre point
  dimensions: "d9" = 5.4864 diameter of C2
extrude "Extrusion4" cut sketch "Sketch4" distance "d10" = 3.5052; taper "d11" = 0 deg
sketch "Sketch5"
  geometry: C1 r 2.743 at (0, 0) reference; C2 r 6.35 at (0, 0) reference
extrude "Extrusion5" cut sketch "Sketch5" distance "d12" = 0.127; taper "d13" = 0 deg
body "Solid1"
