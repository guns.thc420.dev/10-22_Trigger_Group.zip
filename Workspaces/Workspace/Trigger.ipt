# Autodesk Inventor part: Trigger
Saved by Autodesk Inventor 2011 (Build 150239000, 239)
## iProperties
Created: 2011-09
Part Number: Trigger
Document SubType Name: Modeling
Designer: Bob Clark
Manufacturer: Standard
Standards Organization: Custom
Density: 1 g/cm^3
Author: Bob Clark
## Design history (mm, degrees)
sketch "Sketch1"
  geometry: L1 (-9.637, 21.908)-(15.763, 21.908); L2 (15.763, 21.908)-(15.763, -12.509); L3 (15.763, -12.509)-(-9.637, -12.509); L4 (-9.637, -12.509)-(-9.637, 21.908)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular
  dimensions: "d0" = 34.417 distance of L3.end L1.start; "d1" = 25.4 distance of L1.start L1.end
extrude "Extrusion1" new body sketch "Sketch1" distance "d2" = 12.5222; taper "d3" = 0 deg
sketch "Sketch2"
  geometry: L1 (-9.637, 21.908)-(15.763, 21.908) reference; L2 (-9.637, -12.509)-(-9.637, 21.908) reference; L3 (15.763, -12.509)-(-9.637, -12.509) reference; L4 (15.763, 21.908)-(15.763, -12.509) reference; L5 (-9.637, 12.84)-(13.447, 12.84); L6 (-2.974, 20.663)-(12.588, 20.663); L7 (12.588, 20.663)-(13.447, 12.84); L8 (-9.637, 18.072)-(-9.637, 13.265); A1 r 3.835 centre (-5.802, 18.072) between (-2.974, 20.663) and (-9.637, 18.072); 1 further point
  constraints: 8 end point, 3 point on line, 3 tangent, 2 point on circle, 1 centre point, 1 coincident, 1 parallel
  dimensions: "d5" = 9.0678 distance between parallel lines of L1 L5; "d7" = 7.8232 distance between parallel lines of L6 L5; "d8" = 7.6708 diameter of A1
extrude "Extrusion2" cut sketch "Sketch2" distance "d9" = 1.8415; taper "d10" = 0 deg
sketch "Sketch3"
  geometry: L1 (15.763, 21.908)-(15.763, -12.509) reference; L2 (-5.802, 21.908)-(15.763, 21.908) reference; L3 (12.588, 20.663)-(-2.974, 20.663) reference; L4 (13.447, 12.84)-(12.588, 20.663) reference; L5 (15.608, 1.613)-(15.763, 1.613); L6 (13.447, 12.84)-(13.447, 9.487); L7 (13.447, 9.487)-(15.608, 1.613); A1 r 3.835 centre (-5.802, 18.072) between (-2.974, 20.663) and (-5.802, 21.908) reference
  constraints: 6 end point, 1 point on line
  dimensions: "d12" = 19.05 distance between parallel lines of L3 L5
extrude "Extrusion3" cut sketch "Sketch3" stored distance "d13" = 1.8415; taper "d14" = 0 deg
sketch "Sketch4"
  geometry: L1 (-9.637, 21.908)-(-5.802, 21.908) reference; L2 (-9.637, 18.072)-(-9.637, 21.908) reference; A1 r 3.835 centre (-5.802, 18.072) between (-5.802, 21.908) and (-9.637, 18.072) reference
extrude "Extrusion4" cut sketch "Sketch4" stored distance "d15" = 1.8415; taper "d16" = 0 deg
sketch "Sketch5"
  geometry: A1 r 3.835 centre (-5.802, 18.072) between (-2.974, 20.663) and (-9.637, 18.072) reference; 1 further point
  constraints: 1 coincident
hole "Hole1" sketch "Sketch5" at (-5.802, 18.072) diameter "d17" = 3.175; stored, may be unused: countersink angle "d21" = 82 deg, drill point angle "d23" = 118 deg; dims "d18" = 12.7, "d19" = 9.525, "d20" = 6.35, "d22" = 19.05
sketch "Sketch6"
  geometry: L1 (12.588, 20.663)-(-2.974, 20.663) reference; C1 r 1.587 at (-5.802, 18.072) reference; 1 further point
  dimensions: "d24" = 13.716 distance of point (7.913, 17.92) C1.centre; "d32" = 2.7432 distance from line of point (7.913, 17.92) L1
hole "Hole2" sketch "Sketch6" at (7.913, 17.92) diameter "d25" = 2.159; stored, may be unused: countersink angle "d29" = 82 deg, drill point angle "d31" = 118 deg; dims "d26" = 12.7, "d27" = 9.525, "d28" = 6.35, "d30" = 19.05
sketch "Sketch7"
  geometry: L1 (-9.637, 12.84)-(13.447, 12.84) reference; L2 (12.588, 20.663)-(-2.974, 20.663) reference; L3 (-9.637, 14.313)-(13.447, 14.313); L4 (-9.637, 14.313)-(-9.637, 12.84); L5 (13.447, 14.313)-(13.447, 12.84)
  constraints: 6 end point, 2 parallel, 1 perpendicular
  dimensions: "d33" = 6.35 distance between parallel lines of L3 L2
extrude "Extrusion5" cut sketch "Sketch7" stored distance "d34" = 1.8415; taper "d35" = 0 deg
sketch "Sketch8"
  geometry: L1 (13.447, 9.487)-(13.447, 12.84) reference; L2 (13.286, 14.313)-(13.447, 12.84) reference; L3 (13.286, 14.313)-(13.447, 9.487)
  constraints: 2 end point
extrude "Extrusion6" cut sketch "Sketch8" stored distance "d36" = 1.8415; taper "d37" = 0 deg
sketch "Sketch9"
  geometry: L1 (13.447, 9.487)-(13.286, 14.313) reference; L2 (15.763, -12.509)-(-9.637, -12.509) reference; L3 (15.763, 1.613)-(15.608, 1.613) reference; L4 (10.048, 1.613)-(10.048, 1.257); L5 (-9.637, 10.782)-(13.404, 10.782); L6 (3.416, -7.818)-(4.432, -9.906); L7 (10.048, 1.613)-(10.041, 1.613); L8 (15.608, 1.613)-(12.266, -3.022); L9 (-9.637, 10.782)-(-9.637, -12.509); L10 (-9.637, -12.509)-(15.763, -12.509); L11 (15.763, -12.509)-(15.763, 1.613); A1 r 9.525 centre (0.523, 1.257) between (3.416, -7.818) and (0.523, 10.782); A2 r 3.835 centre (-5.802, 18.072) between (-2.974, 20.663) and (-9.637, 18.072) reference; A3 r 13.653 centre (0.02, 3.014) between (4.432, -9.906) and (12.266, -3.022)
  constraints: 16 end point, 6 point on circle, 4 perpendicular, 3 point on line, 2 centre point, 2 tangent, 1 collinear, 1 parallel
  dimensions: "d39" = 11.1252 dimension on A2 L5; "d41" = 9.525 radius of A1
extrude "Extrusion7" cut sketch "Sketch9" stored distance "d42" = 1.8415; taper "d43" = 0 deg
sketch "Sketch10"
  geometry: L1 (0, 0)-(0, -7.29) reference; L2 (0, -3.645)-(1.841, -3.645); L3 (1.841, -3.645)-(1.842, -29.949); L4 (1.842, -29.949)-(0, -29.949); L5 (0, -29.949)-(0, -3.645)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 midpoint, 1 perpendicular
  dimensions: "d44" = 1.8415 distance between parallel lines of L3 L5
extrude "Extrusion8" cut sketch "Sketch10" stored distance "d45" = 1.8415; taper "d46" = 0 deg
sketch "Sketch11"
  geometry: L1 (1.841, -7.29)-(10.681, -7.29) reference; L2 (0, -3.645)-(1.841, -3.645) reference; L3 (6.261, -7.29)-(6.261, -4.115); L4 (3.048, 6.23)-(9.474, 6.23); L5 (9.474, 6.23)-(9.474, -4.115); L6 (9.474, -4.115)-(3.048, -4.115); L7 (3.048, -4.115)-(3.048, 6.23)
  constraints: 10 end point, 2 midpoint, 2 parallel, 2 perpendicular, 1 horizontal
  dimensions: "d47" = 3.175 distance between parallel lines of L6 L1; "d48" = 3.2131 distance between parallel lines of L5 L3; "d50" = 3.2131 distance between parallel lines of L3 L7
extrude "Extrusion9" cut sketch "Sketch11" stored distance "d51" = 1.8415; taper "d52" = 0 deg
fillet "Fillet1" dims "d53" = 2.159
fillet "Fillet2" dims "d54" = 0.79375
chamfer "Chamfer1" distance "d55" = 1.5875; stored, may be unused: second distance "d56" = 3.175, angle "d57" = 45 deg
chamfer "Chamfer2" distance "d58" = 1.5875; stored, may be unused: second distance "d59" = 3.175, angle "d60" = 45 deg
fillet "Fillet3" dims "d61" = 0.79375
fillet "Fillet4" dims "d62" = 0.79375
fillet "Fillet5" dims "d63" = 0.79375
sketch "Sketch13"
  geometry: L1 (-11.743, -14.598)-(-15.086, -9.963) reference; L2 (-14.027, -6.106)-(-15.086, -9.963); L3 (-15.086, -9.963)-(-11.743, -14.598); A1 r 12.413 centre (-1.675, -7.337) between (-14.027, -6.106) and (-11.743, -14.598); 1 further point
  constraints: 4 end point, 2 point on circle, 1 centre point, 1 collinear, 1 tangent
extrude "Extrusion10" cut sketch "Sketch13" distance "d64" = 25.4; taper "d65" = 0 deg
body "Solid1"
other parameters: "d4" = 22.225
