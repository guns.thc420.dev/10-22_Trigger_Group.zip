# Autodesk Inventor assembly: Trigger Group Complete
Saved by Autodesk Inventor 2011 (Build 150239000, 239)
## iProperties
Created: 2011-09
Part Number: Trigger Group Complete
Document SubType Name: Assembly
Designer: Bob Clark
Manufacturer: Standard
Standards Organization: Custom
Author: Bob Clark
## Documents named in this file (6)
- E:\PROJECTS\PERS.PROJECTS\Gray Area\Ruger10-22\Trigger Housing Assy\Trigger Group Complete.iam
- E:\PROJECTS\PERS.PROJECTS\Gray Area\Ruger10-22\Trigger Housing Assy\Trigger Housing.ipt
- E:\PROJECTS\PERS.PROJECTS\Gray Area\Ruger10-22\Trigger Housing Assy\Trigger.ipt
- E:\PROJECTS\PERS.PROJECTS\Gray Area\Ruger10-22\Trigger Housing Assy\Hammer.ipt
- E:\PROJECTS\PERS.PROJECTS\Gray Area\Ruger10-22\Trigger Housing Assy\Hammer Bushing.ipt
- E:\PROJECTS\PERS.PROJECTS\Gray Area\Ruger10-22\Trigger Housing Assy\Sear.ipt
## Components (6 placed, 5 different names)
1. Trigger Housing:1 — Mate:1, Mate:2, Insert:3
2. Trigger:1 — Mate:1, Mate:2, Insert:4
3. Hammer:1 — Insert:1, Insert:2
4. Hammer Bushing:1 — Insert:2
5. Hammer Bushing:2 — Insert:1, Insert:3
6. Sear:1 — Insert:4
## Relationships (6: Insert 4, Mate 2)
- Mate:1: Trigger Housing:1 ↔ Trigger:1
- Mate:2: Trigger Housing:1 ↔ Trigger:1
- Insert:1: Hammer:1 ↔ Hammer Bushing:2
- Insert:2: Hammer:1 ↔ Hammer Bushing:1
- Insert:3: Trigger Housing:1 ↔ Hammer Bushing:2
- Insert:4: Trigger:1 ↔ Sear:1
