# Autodesk Inventor part: Sear
Saved by Autodesk Inventor 2011 (Build 150239000, 239)
## iProperties
Created: 2011-09
Part Number: Sear
Document SubType Name: Modeling
Designer: Bob Clark
Manufacturer: Standard
Standards Organization: Custom
Density: 1 g/cm^3
Author: Bob Clark
## Design history (mm, degrees)
sketch "Sketch1"
  geometry: L1 (10.539, 9.103)-(10.539, -9.339); L2 (10.539, -9.339)-(7.364, -9.339); L3 (-17.645, 10.346)-(10.539, 9.103); L4 (-4.606, 2.601)-(-3.725, 2.562); L5 (-3.725, 2.562)-(-3.508, 2.588); L6 (-18.332, 6.124)-(-4.606, 2.601); L7 (2.31, 3.898)-(2.653, 3.883); L8 (-3.725, 2.562)-(2.31, 3.898); L9 (7.364, -9.339)-(6.532, 0.168); L10 (6.221, 3.726)-(6.221, 3.727); L11 (-17.645, 10.346)-(-18.332, 6.124); C1 r 1.6 at (-4.015, 5.982); A1 r 3.432 centre (-4.015, 5.982) between (-5.126, 2.735) and (-2.836, 2.759); A2 r 4.074 centre (2.474, -0.187) between (6.532, 0.168) and (0.984, 3.604)
  constraints: 22 end point, 8 point on circle, 3 centre point, 3 point on line, 3 tangent, 2 parallel
  dimensions: "d4" = 3.2004 diameter of C1; "d5" = 14.5542 distance from line of C1.centre L1; "d10" = 92.5254 deg angle of L3 L1 (derived); "d12" = 7.1628 distance between parallel lines of L4 L3; "d17" = 5.5626 distance between parallel lines of L7 L3; "d18" = 8.14726 diameter of A2
extrude "Extrusion1" new body sketch "Sketch1" distance "d19" = 5.9182; taper "d20" = 0 deg
sketch "Sketch2"
  geometry: L1 (0, 0)-(0, 5.918) reference; L2 (12.208, 0)-(12.208, 5.918) reference; L3 (15.409, 0)-(15.409, 5.918) reference; C1 r 1.672 at (7.938, 2.959)
  constraints: 1 centre point
  dimensions: "d21" = 7.9375 distance from line of C1.centre L1
extrude "Extrusion2" cut sketch "Sketch2" distance "d22" = 3.556; taper "d23" = 0 deg
sketch "Sketch3"
  geometry: L1 (10.539, -9.339)-(10.539, 9.103) reference; L2 (10.539, 9.103)-(-17.645, 10.346) reference; L3 (-4.606, 2.601)-(-3.725, 2.562) reference; L4 (-3.725, 2.562)-(2.31, 3.898) reference; L5 (9.98, 8.492)-(10.539, 8.467); L6 (10.539, 5.967)-(9.98, 8.492); L7 (10.539, 8.467)-(10.539, 5.967)
  constraints: 6 end point, 2 point on line, 1 parallel, 1 perpendicular
  dimensions: "d24" = 0.635 distance between parallel lines of L5 L2
extrude "Extrusion3" cut sketch "Sketch3" stored distance "d28" = 3.556; taper "d29" = 0 deg
sketch "Sketch4"
  geometry: L1 (9.98, 8.492)-(10.539, 8.467) reference; L2 (10.539, 8.467)-(10.539, 9.103) reference; L3 (9.98, 8.492)-(10.539, 8.785)
  constraints: 2 end point, 1 midpoint
extrude "Extrusion4" cut sketch "Sketch4" stored distance "d30" = 3.556; taper "d31" = 0 deg
sketch "Sketch5"
  geometry: L1 (10.539, 8.785)-(10.539, 9.103) reference; L2 (10.539, 9.103)-(-17.645, 10.346) reference; L3 (-4.015, 5.982)-(-3.553, 9.725); L4 (-3.553, 9.725)-(10.539, 8.785); C1 r 1.6 at (-4.015, 5.982) reference
  constraints: 4 end point, 1 midpoint
extrude "Extrusion5" cut sketch "Sketch5" stored distance "d32" = 3.556; taper "d33" = 0 deg
fillet "Fillet1" dims "d34" = 0.0508
body "Solid1"
other parameters: "d6" = 2.159, "d14" = 5 deg
