# Autodesk Inventor part: Hammer
Saved by Autodesk Inventor 2011 (Build 150239000, 239)
## iProperties
Created: 2011-09
Part Number: Hammer
Document SubType Name: Modeling
Designer: Bob Clark
Manufacturer: Standard
Standards Organization: Custom
Density: 1 g/cm^3
Author: Bob Clark
## Design history (mm, degrees)
sketch "Sketch1"
  geometry: L1 (0.816, 1.475)-(0.816, -11.456); L2 (0.816, 1.396)-(0.828, 1.396); L3 (0.828, 1.396)-(-0.034, 7.368); L4 (-0.034, 7.368)-(0.725, 24.52); L5 (-13.343, 5.415)-(-13.343, 7.554); L6 (-10.273, 8.358)-(-13.343, 7.554); L7 (-10.592, 25.621)-(-11.011, 16.144); L8 (-13.343, 5.415)-(-11.029, 3.832); L9 (-9.956, -9.137)-(-9.848, -9.142); L10 (-9.848, -9.142)-(-10.232, -9.388); L11 (-10.974, 3.727)-(-10.974, 0.465); L12 (-0.516, 26.456)-(-8.723, 26.819); L13 (-8.723, 26.819)-(-10.592, 25.621); L14 (-0.516, 26.456)-(0.725, 24.52); C1 r 2.731 at (-3.921, -6.219); C2 r 2.438 at (-5.915, 1.821); A1 r 7.062 centre (-3.921, -6.219) between (-10.232, -9.388) and (0.816, -11.456); A2 r 4.153 centre (-12.035, 12.119) between (-10.273, 8.358) and (-11.011, 16.144); A3 r 6.704 centre (-3.921, -6.219) between (-10.36, -8.086) and (-9.929, -9.194); A4 r 15.902 centre (5.1, -4.36) between (-10.36, -0.634) and (-10.36, -8.086); A5 r 1.356 centre (-11.715, -0.67) between (-10.36, -0.634) and (-10.974, 0.465); A6 r 0.127 centre (-11.101, 3.727) between (-10.974, 3.727) and (-11.029, 3.832)
  constraints: 28 end point, 13 point on circle, 8 centre point, 4 parallel, 3 perpendicular, 3 point on line, 2 tangent
extrude "Extrusion1" new body sketch "Sketch1" distance "d23" = 6.985; taper "d24" = 0 deg
workplane "Work Plane1"
sketch "Sketch2"
  geometry: C1 r 11.528 at (-18.014, 5.289)
  constraints: 1 centre point
extrude "Extrusion2" cut sketch "Sketch2" stored distance "d26" = 2.54; taper "d27" = 0 deg
body "Solid1"
other parameters: "d19" = 25.4, "d25" = -3.4925
