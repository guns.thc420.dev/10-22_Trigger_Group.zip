# Autodesk Inventor part: Trigger Housing
Saved by Autodesk Inventor 2011 (Build 150239000, 239)
## iProperties
Created: 2011-09
Part Number: Trigger Housing
Document SubType Name: Modeling
Designer: Bob Clark
Manufacturer: Standard
Standards Organization: Custom
Density: 1 g/cm^3
Author: Bob Clark
## Design history (mm, degrees)
sketch "Sketch1"
  geometry: L1 (-31.32, 19.482)-(62.609, 19.482); L2 (62.609, 19.482)-(62.609, -5.918); L3 (62.609, -5.918)-(-31.32, -5.918); L4 (-31.32, -5.918)-(-31.32, 19.482)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular
  dimensions: "d0" = 25.4 distance of L3.end L1.start; "d1" = 93.9292 distance of L1.start L1.end
extrude "Extrusion1" new body sketch "Sketch1" distance "d2" = 24.638; taper "d3" = 0 deg
sketch "Sketch2"
  geometry: L1 (-24.97, 19.482)-(-31.32, 19.482) reference; L2 (-31.32, 19.482)-(-31.32, -5.918) reference; L3 (-31.32, -5.918)-(-24.97, -5.918) reference; L4 (-24.97, -5.918)-(-24.97, 19.482) reference; L5 (62.609, 19.482)-(62.609, -5.918) reference; L6 (-24.97, 19.482)-(62.609, 19.482) reference; L7 (46.099, 18.346)-(46.099, 9.93); A1 r 2.381 centre (-23.72, 13.513) between (-21.338, 13.513) and (-26.101, 13.513); A2 r 2.381 centre (43.717, 13.513) between (46.099, 13.513) and (41.336, 13.513); A3 r 2.381 centre (43.717, 13.513) between (41.336, 13.513) and (46.099, 13.513); A4 r 2.381 centre (-23.72, 13.513) between (-26.101, 13.513) and (-21.338, 13.513); 2 further points
  constraints: 8 point on circle, 4 centre point, 2 coincident, 2 end point, 1 perpendicular, 1 tangent
  dimensions: "d16" = 5.969 distance from line of A2.centre L6; "d17" = 5.969 distance from line of A1.centre L6; "d18" = 16.51 distance between parallel lines of L7 L5; "d19" = 67.437 distance of A2.centre A1.centre
hole "Hole1" sketch "Sketch2" at (-23.72, 13.513), (43.717, 13.513) diameter "d5" = 4.7625; stored, may be unused: countersink angle "d9" = 82 deg, drill point angle "d11" = 118 deg; dims "d6" = 12.7, "d7" = 9.525, "d8" = 6.35, "d10" = 19.05
sketch "Sketch3"
  geometry: L1 (-87.579, 0)-(0, 0) reference; L2 (0, 24.638)-(0, 0) reference; L3 (0, 24.638)-(-87.579, 24.638) reference; L4 (-93.929, 18.288)-(-93.929, 6.35) reference; A1 r 6.35 centre (-87.579, 6.35) between (-93.929, 6.35) and (-87.579, 0) reference; A2 r 6.35 centre (-87.579, 18.288) between (-87.579, 24.638) and (-93.929, 18.288) reference
extrude "Extrusion2" join sketch "Sketch3" distance "d12" = 5.0292; taper "d13" = 0 deg
sketch "Sketch4"
  geometry: L1 (-31.32, 19.482)-(62.609, 19.482) reference; L2 (-24.97, -5.918)-(-24.97, -10.947) reference; L3 (62.609, 19.482)-(62.609, -10.947) reference; L4 (-31.32, 19.482)-(-28.73, 19.482); L5 (-28.73, 19.482)-(-28.73, -0.279); L6 (-28.73, -0.279)-(-31.32, -0.279); L7 (-31.32, -0.279)-(-31.32, 19.482); L8 (-36.096, 2.345)-(-36.096, -15.214)
  constraints: 10 end point, 3 parallel, 1 horizontal, 1 perpendicular
  dimensions: "d20" = 91.3384 distance between parallel lines of L3 L5; "d21" = 19.7612 distance between parallel lines of L1 L6; "d22" = 98.7044 distance between parallel lines of L8 L3
extrude "Extrusion3" cut sketch "Sketch4" stored distance "d23" = 25.4; taper "d24" = 0 deg
sketch "Sketch5"
  geometry: L1 (-31.32, -5.918)-(-31.32, -0.279) reference; L2 (-24.97, -5.918)-(-31.32, -5.918) reference; L3 (-24.97, -5.918)-(-24.97, -10.947) reference; L4 (-28.73, 19.482)-(-28.73, -0.279) reference; L5 (-31.32, -0.279)-(-36.098, -0.279); L6 (-24.97, -10.947)-(-36.098, -10.947); L7 (-36.098, -0.279)-(-36.098, -10.947)
  constraints: 6 end point, 2 perpendicular, 1 parallel
extrude "Extrusion4" join sketch "Sketch5" stored distance "d25" = 25.4; taper "d26" = 0 deg
sketch "Sketch6"
  geometry: L1 (28.73, -0.279)-(28.73, 19.482) reference; L2 (-62.609, 19.482)-(28.73, 19.482) reference; L3 (-62.609, -10.947)-(-62.609, 19.482) reference; L4 (-62.609, -10.947)-(36.098, -10.947) reference; L5 (36.098, -10.947)-(36.098, -0.279) reference; L6 (36.098, -0.279)-(28.73, -0.279) reference; C1 r 2.381 at (23.72, 13.513) reference; C2 r 2.381 at (-43.717, 13.513) reference
extrude "Extrusion5" join sketch "Sketch6" distance "d27" = 31.5976; taper "d28" = 0 deg
sketch "Sketch7"
  geometry: L1 (-31.598, 30.429)-(0, 30.429) reference; L2 (-31.598, 0)-(0, 0) reference; L3 (-31.598, 30.429)-(-28.004, 30.429); L4 (-28.004, 30.429)-(-28.004, 9.576); L5 (-28.004, 9.576)-(-31.598, 9.576); L6 (-31.598, 9.576)-(-31.598, 30.429); L7 (0, 30.429)-(-3.594, 30.429); L8 (-3.594, 30.429)-(-3.594, 9.576); L9 (-3.594, 9.576)-(0, 9.576); L10 (0, 9.576)-(0, 30.429); L11 (-15.799, 0)-(-15.799, 30.429)
  constraints: 18 end point, 4 parallel, 2 horizontal, 2 midpoint, 2 perpendicular
  dimensions: "d29" = 24.4094 distance between parallel lines of L4 L8; "d30" = 12.2047 distance between parallel lines of L4 L11; "d31" = 20.8534 distance of L7.end L8.end; "d32" = 20.8534 distance of L3.end L4.end
extrude "Extrusion6" cut sketch "Sketch7" stored distance "d33" = 31.5976; taper "d34" = 0 deg
sketch "Sketch8"
  geometry: L1 (58.189, -10.947)-(58.189, -1.371); L2 (-36.098, -1.371)-(58.189, -1.371); L3 (58.189, -1.371)-(58.189, -10.947); L4 (58.189, -10.947)-(-36.098, -10.947); L5 (-36.098, -10.947)-(-36.098, -1.371)
  constraints: 10 end point, 2 parallel, 1 horizontal, 1 perpendicular
extrude "Extrusion7" cut sketch "Sketch8" stored distance "d35" = 31.5976; taper "d36" = 0 deg
sketch "Sketch9"
  geometry: L1 (-58.189, -10.947)-(-58.189, -1.371) reference; L2 (-58.189, -1.371)-(36.098, -1.371); L3 (36.098, -1.371)-(36.098, -10.947); L4 (36.098, -10.947)-(-58.189, -10.947); L5 (-58.189, -10.947)-(-58.189, -1.371)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular
extrude "Extrusion8" cut sketch "Sketch9" stored distance "d37" = 31.5976; taper "d38" = 0 deg
sketch "Sketch10"
  geometry: L1 (0, 20.853)-(0, 0) reference; L2 (-91.338, 20.853)-(0, 20.853) reference; L3 (-99.079, 9.677)-(-7.595, 9.677); L4 (-4.42, 6.502)-(-4.42, -2.007); L5 (-7.595, -5.182)-(-99.079, -5.182); L6 (-99.079, -5.182)-(-99.079, 9.677); A1 r 3.175 centre (-7.595, 6.502) between (-4.42, 6.502) and (-7.595, 9.677); A2 r 3.175 centre (-7.595, -2.007) between (-7.595, -5.182) and (-4.42, -2.007)
  constraints: 8 end point, 4 point on circle, 4 tangent, 2 centre point, 2 parallel, 1 equal radius, 1 horizontal, 1 perpendicular
  dimensions: "d39" = 11.176 distance between parallel lines of L3 L2; "d40" = 14.859 distance between parallel lines of L5 L3; "d41" = 4.4196 distance between parallel lines of L4 L1; "d42" = 3.175 radius of A1
extrude "Extrusion9" cut sketch "Sketch10" distance "d43" = 2.667; taper "d44" = 0 deg
sketch "Sketch11"
  geometry: L1 (91.338, 1.092)-(98.706, 1.092) reference; L2 (4.42, -2.007)-(4.42, 6.502) reference; L3 (7.595, 9.677)-(91.338, 9.677) reference; L4 (98.706, -5.182)-(7.595, -5.182) reference; L5 (4.42, -2.007)-(4.42, 6.502); L6 (7.595, 9.677)-(91.338, 9.677); L7 (90.672, 9.677)-(91.338, 9.677); L8 (91.338, 1.092)-(91.338, 9.677); L9 (91.338, 1.092)-(98.706, 1.092); L10 (98.706, 1.092)-(98.706, -5.182); L11 (7.595, -5.182)-(98.706, -5.182); A1 r 3.175 centre (7.595, 6.502) between (7.595, 9.677) and (4.42, 6.502) reference; A2 r 3.175 centre (7.595, -2.007) between (4.42, -2.007) and (7.595, -5.182) reference; A3 r 3.175 centre (7.595, 6.502) between (7.595, 9.677) and (4.42, 6.502); A4 r 3.175 centre (7.595, -2.007) between (4.42, -2.007) and (7.595, -5.182)
  constraints: 15 end point, 8 tangent, 5 point on circle, 4 collinear, 2 centre point, 2 coincident, 2 concentric, 2 perpendicular, 1 point on line
extrude "Extrusion10" cut sketch "Sketch11" distance "d45" = 2.667; taper "d46" = 0 deg
sketch "Sketch12"
  geometry: L1 (-11.227, -5.182)-(-7.595, -5.182); L2 (-4.42, -5.182)-(-4.42, -9.576); L3 (-4.42, -9.576)-(-11.227, -9.576); L4 (-11.227, -9.576)-(-11.227, -5.182); L5 (0, 0)-(0, -9.576) reference; L6 (-4.42, -2.007)-(-4.42, -5.182); A1 r 3.175 centre (-7.595, -2.007) between (-7.595, -5.182) and (-4.42, -2.007) reference; A2 r 3.175 centre (-7.595, -2.007) between (-7.595, -5.182) and (-4.42, -2.007)
  constraints: 10 end point, 3 point on circle, 2 parallel, 1 centre point, 1 coincident, 1 concentric, 1 horizontal, 1 perpendicular
  dimensions: "d47" = 11.2268 distance between parallel lines of L4 L5
extrude "Extrusion11" join sketch "Sketch12" stored distance "d48" = 2.3368; taper "d49" = 0 deg
sketch "Sketch13"
  geometry: L1 (98.706, -5.182)-(7.595, -5.182) reference; L2 (4.42, -2.007)-(4.42, 6.502) reference; L3 (11.227, -9.576)-(11.227, -5.182) reference; L4 (4.42, -9.576)-(4.42, 0) reference; L5 (11.227, -5.182)-(11.227, -9.576); L6 (11.227, -9.576)-(4.42, -9.576); L7 (4.42, -9.576)-(4.42, -2.007); L8 (11.227, -5.182)-(7.595, -5.182); A1 r 3.175 centre (7.595, -2.007) between (4.42, -2.007) and (7.595, -5.182) reference; A2 r 3.175 centre (7.595, -2.007) between (4.42, -2.007) and (7.595, -5.182)
  constraints: 10 end point, 2 point on circle, 1 centre point, 1 coincident, 1 collinear, 1 concentric, 1 perpendicular, 1 tangent
extrude "Extrusion12" join sketch "Sketch13" stored distance "d50" = 2.3368; taper "d51" = 0 deg
fillet "Fillet2" dims "d52" = 3.175
fillet "Fillet3" dims "d53" = 3.175
sketch "Sketch14"
  geometry: L1 (22.631, 2.743)-(22.631, 8.153); L2 (22.631, 8.153)-(8.966, 8.153); L3 (8.966, 8.153)-(8.966, 2.743); L4 (22.631, 2.743)-(24.447, 0); L5 (8.966, 2.743)-(7.15, 0); L6 (22.631, 0)-(24.447, 0); L7 (7.15, 0)-(24.447, 0)
  constraints: 14 end point, 1 parallel, 1 point on line
extrude "Extrusion13" cut sketch "Sketch14" distance "d67" = 11.6332; taper "d68" = 0 deg
sketch "Sketch15"
  geometry: L1 (28.004, 9.576)-(28.003, 30.429) reference; L2 (3.594, 30.429)-(3.594, 9.576) reference; L3 (8.966, 8.153)-(22.631, 8.153) reference; C1 r 6.096 at (15.799, 19.329); C2 r 1.88 at (15.799, 19.329)
  constraints: 2 centre point
  dimensions: "d69" = 12.192 diameter of C1; "d70" = 3.7592 diameter of C2; "d82" = 11.176 distance from line of C1.centre L3; "d83" = 12.2047 distance from line of C1.centre L1; "d84" = 12.2047 distance from line of C1.centre L2 (derived)
extrude "Extrusion14" join sketch "Sketch15" distance "d71" = 3.3274; taper "d72" = 0 deg
workaxis "Work Axis1"
workplane "Work Plane1"
sketch "Sketch16"
  geometry: L1 (3.327, 6.096)-(3.327, -6.096) reference; L2 (0, 6.096)-(0, -6.096) reference; L3 (0, 1.88)-(3.327, 1.88) reference; L4 (0, 0)-(3.327, 0); L5 (0.429, -6.096)-(3.327, -2.237); L6 (0.429, -6.096)-(3.327, -6.096); L7 (3.327, -6.096)-(3.327, -2.237); L8 (-119.113, 0)-(23.734, 0) reference
  constraints: 8 end point, 2 midpoint, 2 perpendicular, 1 point on line
revolve "Revolution1" sketch "Sketch16" stored, may be unused: angle "d74" = 90 deg
sketch "Sketch17"
  geometry: L1 (0, 0)-(91.338, 0) reference; L2 (91.338, 24.409)-(80.721, 24.409); L3 (80.721, 24.409)-(80.721, 0); L4 (80.721, 0)-(91.338, 0); L5 (91.338, 0)-(91.338, 24.409)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 1 point on line
  dimensions: "d75" = 10.6172 distance between parallel lines of L3 L5
extrude "Extrusion15" join sketch "Sketch17" distance "d76" = 4.7625; taper "d77" = 0 deg
sketch "Sketch18"
  geometry: L1 (-6.198, 21.984)-(-2.565, 25.616); L2 (-6.198, 21.984)-(-6.198, 25.616); L3 (-6.198, 25.616)-(-2.565, 25.616)
  constraints: 6 end point, 1 perpendicular
extrude "Extrusion16" cut sketch "Sketch18" stored distance "d80" = 4.7625; taper "d81" = 0 deg
sketch "Sketch19"
  geometry: L1 (0, 0)-(7.15, 0) reference; L2 (7.15, 0)-(0, 1.916); L3 (15.799, 8.153)-(15.799, 19.329); L4 (0, 0)-(7.15, 0); L5 (0, 0)-(0, 1.916); C1 r 6.096 at (15.799, 19.329) reference
  constraints: 8 end point, 1 collinear
extrude "Extrusion17" cut sketch "Sketch19" distance "d87" = 13.97; taper "d88" = 0 deg
sketch "Sketch21"
  geometry: L1 (-54.557, -6.553)-(-54.557, -10.947) reference; L2 (-54.557, -6.553)-(-55.014, -6.553) reference; L3 (-58.189, -3.378)-(-58.189, -10.947) reference; L4 (-58.189, -10.947)-(-54.557, -10.947) reference; L5 (-57.386, -10.947)-(-58.933, -10.947); L6 (-58.933, -10.947)-(-58.933, -5.557); L7 (-58.933, -5.557)-(-57.386, -5.557); L8 (-57.386, -5.557)-(-57.386, -10.947); A1 r 3.175 centre (-55.014, -3.378) between (-58.189, -3.378) and (-55.014, -6.553) reference
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 1 point on line
extrude "Extrusion19" join sketch "Sketch21" stored distance "d91" = 11.684; taper "d92" = 0 deg
sketch "Sketch22"
  geometry: L1 (-54.557, -6.553)-(-55.014, -6.553) reference; L2 (-58.189, -3.085)-(-59.264, -3.085); L3 (-59.264, -3.085)-(-59.264, -5.974); L4 (-59.264, -5.974)-(-58.189, -5.974); L5 (-58.189, -3.085)-(-58.176, -3.085); L6 (-57.38, -5.495)-(-57.38, -5.974); L7 (-57.38, -5.974)-(-58.189, -5.974); A1 r 3.175 centre (-55.014, -3.378) between (-58.176, -3.085) and (-57.38, -5.495)
  constraints: 13 end point, 2 horizontal, 2 parallel, 2 perpendicular, 2 point on circle, 1 centre point
extrude "Extrusion20" join sketch "Sketch22" stored distance "d93" = 11.684; taper "d94" = 0 deg
sketch "Sketch23"
  geometry: L1 (-11.633, 7.15)-(-11.633, 24.448) reference; L2 (-98.706, 3.594)-(-98.706, 28.004) reference; L3 (-98.706, 3.594)-(-13.773, 3.594) reference; L4 (-22.733, 21.831)-(-22.733, 9.766); L5 (0, 31.598)-(0, 24.448) reference; L6 (-22.733, 21.831)-(-11.633, 21.831); L7 (-22.733, 9.766)-(-11.633, 9.766); L8 (-11.633, 21.831)-(-11.633, 9.766); L9 (-98.706, 15.799)-(-22.733, 15.799); L10 (-11.633, 15.799)-(17.415, 15.799)
  constraints: 12 end point, 3 midpoint, 3 parallel, 3 perpendicular, 2 point on line
  dimensions: "d95" = 22.733 distance between parallel lines of L4 L5
extrude "Extrusion21" cut sketch "Sketch23" stored distance "d98" = 11.684; taper "d99" = 0 deg
fillet "Fillet4" dims "d100" = 1.5875
fillet "Fillet5" dims "d101" = 1.5875
fillet "Fillet6" dims "d102" = 1.5875
fillet "Fillet7" dims "d103" = 1.5875
fillet "Fillet8" dims "d104" = 1.5875
fillet "Fillet9" dims "d105" = 1.5875
fillet "Fillet10" dims "d106" = 1.5875
sketch "Sketch24"
  geometry: L1 (-7.15, 0)-(0, 0) reference; L2 (0, 0)-(0, 9.576) reference; L3 (-7.15, 0)-(0, 1.916)
  constraints: 2 end point, 1 point on line
extrude "Extrusion22" cut sketch "Sketch24" distance "d107" = 11.684; taper "d108" = 0 deg
fillet "Fillet11" dims "d109" = 1.5875
fillet "Fillet12" dims "d110" = 1.5875
sketch "Sketch25"
  geometry: L1 (3.594, 0)-(0, 0) reference; L2 (-24.409, 0)-(-28.004, 0) reference; L3 (0, 0)-(3.594, -0.559); L4 (-28.004, -0.559)-(-24.409, 0); L5 (-24.409, 0)-(-28.004, 0); L6 (-28.004, 0)-(-28.004, -0.559); L7 (0, 0)-(3.594, 0); L8 (3.594, 0)-(3.594, -0.559)
  constraints: 12 end point, 2 collinear, 1 perpendicular
extrude "Extrusion23" cut sketch "Sketch25" distance "d111" = 11.684; taper "d112" = 0 deg
sketch "Sketch26"
  geometry: L1 (0, 24.409)-(0, 0) reference; L2 (0, 0)-(80.721, 0) reference; L3 (0, 24.409)-(28.575, 24.409); L4 (28.575, 24.409)-(28.575, 0); L5 (28.575, 0)-(0, 0); L6 (0, 0)-(0, 24.409)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 1 point on line
  dimensions: "d113" = 28.575 distance between parallel lines of L4 L1
extrude "Extrusion24" cut sketch "Sketch26" distance "d114" = 1.0668; taper "d115" = 0 deg
fillet "Fillet13" dims "d116" = 1.0668
sketch "Sketch27"
  geometry: L1 (83.272, 0)-(0, 0) reference; L2 (0, 4.394)-(53.774, 4.394); L3 (53.774, 4.394)-(53.774, 0); L4 (53.774, 0)-(0, 0); L5 (0, 0)-(0, 4.394); L6 (98.706, 35.192)-(98.706, 9.576) reference
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 1 point on line
  dimensions: "d118" = 44.9326 distance between parallel lines of L3 L6
extrude "Extrusion25" cut sketch "Sketch27" stored distance "d119" = 1.0668; taper "d120" = 0 deg
sketch "Sketch28"
  geometry: L1 (0, 4.394)-(0, 0) reference; L2 (0, 4.394)-(-84.934, 4.394) reference; L3 (-53.774, 4.394)-(-53.774, 0) reference; L4 (-53.774, 4.394)-(0, 4.394); L5 (0, 4.394)-(0, 0); L6 (0, 0)-(-53.774, 0); L7 (-53.774, 0)-(-53.774, 4.394)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular
extrude "Extrusion26" cut sketch "Sketch28" stored distance "d121" = 1.0668; taper "d122" = 0 deg
fillet "Fillet15" dims "d123" = 9.525
sketch "Sketch29"
  geometry: L1 (-0.263, 8.585)-(-3.175, 8.585) reference; L2 (21.234, 8.585)-(18.322, 8.585) reference; L3 (-0.263, 8.585)-(18.059, 8.585); L4 (18.059, 8.585)-(18.059, 0); L5 (18.059, 0)-(-0.263, 0); L6 (-0.263, 0)-(-0.263, 8.585)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular
extrude "Extrusion27" cut sketch "Sketch29" distance "d124" = 2.159; taper "d125" = 0 deg
sketch "Sketch30"
  geometry: L1 (0, 0)-(0, 8.585) reference; L2 (0, 0)-(2.148, 0) reference; L3 (2.148, 8.585)-(2.148, 0) reference; L4 (0, 8.585)-(2.148, 8.585) reference
extrude "Extrusion28" cut sketch "Sketch30" stored distance "d126" = 2.159; taper "d127" = 0 deg
sketch "Sketch31"
  geometry: L1 (0, 0)-(0, 8.585) reference; L2 (2.159, 0)-(0, 0) reference; L3 (2.159, 8.585)-(2.159, 0) reference; L4 (2.159, 8.585)-(0, 8.585) reference
extrude "Extrusion29" cut sketch "Sketch31" stored distance "d128" = 2.159; taper "d129" = 0 deg
sketch "Sketch32"
  geometry: L1 (91.338, -15.938)-(91.338, -5.829) reference; L2 (88.163, -5.829)-(91.338, -5.829) reference; L3 (91.338, -15.938)-(88.163, -15.938) reference; L4 (89.179, -24.524)-(89.179, -15.938) reference; L5 (89.751, -15.938)-(91.338, -15.938); L6 (91.338, -15.938)-(91.338, -5.829); L7 (91.338, -5.829)-(89.751, -5.829); L8 (89.751, -5.829)-(89.751, -15.938)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 midpoint, 1 perpendicular
extrude "Extrusion30" cut sketch "Sketch32" stored distance "d130" = 2.159; taper "d131" = 0 deg
fillet "Fillet16" dims "d132" = 9.525
fillet "Fillet17" dims "d133" = 3.175
fillet "Fillet18" dims "d134" = 4.7625
fillet "Fillet19" dims "d135" = 3.175
fillet "Fillet20" dims "d136" = 3.175
fillet "Fillet21" dims "d137" = 0.79375
fillet "Fillet22" dims "d138" = 0.79375
fillet "Fillet23" dims "d139" = 0.79375
fillet "Fillet24" dims "d140" = 0.79375
fillet "Fillet25" dims "d141" = 0.79375
fillet "Fillet26" dims "d142" = 0.79375
fillet "Fillet27" dims "d143" = 0.79375
fillet "Fillet28" dims "d144" = 0.79375
sketch "Sketch33"
  geometry: L1 (0, 5.41)-(13.665, 5.41) reference; L2 (4.674, 5.41)-(8.992, 5.41); L3 (8.992, 5.41)-(8.992, 10.49); L4 (8.992, 10.49)-(4.674, 10.49); L5 (4.674, 10.49)-(4.674, 5.41); C1 r 6.096 at (6.833, 16.586) reference
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 1 point on line, 1 tangent
extrude "Extrusion31" cut sketch "Sketch33" distance "d147" = 2.159; taper "d148" = 0 deg
sketch "Sketch34"
  geometry: L1 (0, -1.239)-(0, -7.66) reference; L2 (-98.706, 0.298)-(-98.706, -9.576) reference; L3 (-89.181, -9.576)-(-98.706, -9.576) reference; L4 (-23.139, -9.576)-(-23.139, -11.735); L5 (-30.162, -24.384)-(-45.403, -24.384); L6 (-61.697, 20.853)-(-10.617, 20.853) reference; L7 (-62.763, 19.787)-(-84.988, 19.787) reference; L8 (-89.751, 19.787)-(-84.988, 19.787) reference; L9 (-89.751, 19.787)-(-89.751, 10.471) reference; L10 (0, 25.616)-(0, 0) reference; L11 (-23.139, -11.735)-(-19.832, -11.735); L12 (-45.403, -22.253)-(-45.403, -24.384); L13 (-89.751, -9.576)-(-89.181, -9.576); L14 (-52.986, -9.576)-(-23.139, -9.576); A1 r 20.546 centre (-9.838, -27.394) between (-23.139, -11.735) and (-30.162, -24.384); A2 r 16.573 centre (-61.952, -23.514) between (-45.403, -24.384) and (-52.986, -9.576)
  constraints: 13 end point, 4 perpendicular, 4 point on circle, 2 centre point, 2 horizontal, 2 parallel, 1 point on line
  dimensions: "d149" = 23.1394 distance between parallel lines of L4 L1; "d150" = 45.2374 distance between parallel lines of L6 L5; "d153" = 15.24 distance from line of L5.start L12; "d156" = 30.1625 distance from line of L1 L5.start
extrude "Extrusion32" join sketch "Sketch34" stored distance "d158" = 2.159; taper "d159" = 0 deg
sketch "Sketch35"
  geometry: L1 (-61.697, 20.853)-(-10.617, 20.853) reference; L2 (-62.763, 19.787)-(-84.988, 19.787) reference; L3 (-70.881, -36.698)-(-53.472, -36.698); L4 (-87.521, -19.004)-(-87.615, -22.845); L5 (-70.881, -39.873)-(-51.47, -39.873); L6 (-87.622, -23.137)-(-87.617, -23.137); L7 (-98.706, -9.576)-(-70.881, -9.576); L8 (-45.403, -24.384)-(-39.436, -24.384); A1 r 16.561 centre (-61.916, -23.137) between (-51.469, -35.987) and (-45.403, -24.384); A2 r 19.736 centre (-61.916, -23.137) between (-51.274, -39.758) and (-42.552, -26.946); A3 r 3.175 centre (-52.986, -37.084) between (-51.47, -39.873) and (-51.274, -39.758); A4 r 3.175 centre (-53.472, -33.523) between (-53.472, -36.698) and (-51.469, -35.987); A5 r 3.175 centre (-39.436, -27.559) between (-39.436, -24.384) and (-42.552, -26.946); A6 r 13.561 centre (-70.881, -23.137) between (-70.881, -9.576) and (-70.881, -36.698); A7 r 11.349 centre (-98.706, -20.925) between (-87.521, -19.004) and (-98.706, -9.576); A8 r 16.736 centre (-70.881, -23.137) between (-87.615, -22.845) and (-70.881, -39.873)
  constraints: 17 point on circle, 12 end point, 8 centre point, 8 tangent, 1 equal radius, 1 parallel, 1 point on line
  dimensions: "d168" = 3.175 radius of A5
extrude "Extrusion33" join sketch "Sketch35" stored distance "d175" = 2.159; taper "d176" = 0 deg
sketch "Sketch36"
  geometry: L1 (-87.521, -19.004)-(-87.615, -22.845) reference; L2 (-93.82, -27.559)-(-93.82, -41.785); L3 (-93.82, -41.785)-(-39.436, -41.785); L4 (-39.436, -41.785)-(-39.436, -24.384); L5 (-70.881, -9.576)-(-98.706, -9.576); L6 (-98.706, -9.576)-(-98.706, -27.559); L7 (-70.881, -24.384)-(-70.881, -9.576); L8 (-39.436, -24.384)-(-70.881, -24.384); L9 (-87.571, -24.384)-(-87.652, -24.384); L10 (-98.706, -27.559)-(-93.82, -27.559); A1 r 16.736 centre (-70.881, -23.137) between (-87.615, -22.845) and (-70.881, -39.873) reference
  constraints: 18 end point, 5 parallel, 3 horizontal, 3 perpendicular, 1 point on circle, 1 point on line
extrude "Extrusion34" cut sketch "Sketch36" distance "d177" = 3.175; taper "d178" = 0 deg
sketch "Sketch37"
  geometry: L1 (70.881, -36.698)-(53.472, -36.698) reference; L2 (51.47, -39.873)-(70.881, -39.873) reference; L3 (87.615, -22.845)-(87.521, -19.004) reference; L4 (98.706, -9.576)-(89.181, -9.576) reference; L5 (70.881, -9.576)-(96.281, -9.576) reference; L6 (39.436, -24.384)-(45.403, -24.384) reference; A1 r 13.561 centre (70.881, -23.137) between (70.881, -36.698) and (70.881, -9.576) reference; A2 r 3.175 centre (53.472, -33.523) between (51.469, -35.987) and (53.472, -36.698) reference; A3 r 16.561 centre (61.916, -23.137) between (45.403, -24.384) and (51.469, -35.987) reference; A4 r 3.175 centre (39.436, -27.559) between (42.552, -26.946) and (39.436, -24.384) reference; A5 r 19.736 centre (61.916, -23.137) between (42.552, -26.946) and (51.274, -39.758) reference; A6 r 3.175 centre (52.986, -37.084) between (51.274, -39.758) and (51.47, -39.873) reference; A7 r 16.736 centre (70.881, -23.137) between (70.881, -39.873) and (87.615, -22.845) reference; A8 r 11.349 centre (98.706, -20.925) between (98.706, -9.576) and (87.521, -19.004) reference
extrude "Extrusion35" cut sketch "Sketch37" distance "d179" = 3.175; taper "d180" = 0 deg
fillet "Fillet29" dims "d181" = 1.5875
fillet "Fillet30" dims "d182" = 1.5875
fillet "Fillet31" dims "d183" = 1.5875
fillet "Fillet32" dims "d184" = 1.5875
fillet "Fillet33" dims "d185" = 1.5875
sketch "Sketch38"
  geometry: L1 (-61.697, 20.853)-(-10.617, 20.853) reference; L2 (0, -1.239)-(0, -7.66) reference; C1 r 3.969 at (-37.363, -16.51)
  constraints: 1 centre point
  dimensions: "d186" = 37.3634 distance from line of C1.centre L1; "d187" = 37.3634 distance from line of C1.centre L2; "d188" = 7.9375 diameter of C1
extrude "Extrusion36" cut sketch "Sketch38" stored distance "d189" = 3.175; taper "d190" = 0 deg
sketch "Sketch39"
  geometry: L1 (6.985, 0)-(6.985, -25.616) reference; 1 further point
  dimensions: "d191" = 33.1216 distance from line of point (-26.137, -10.731) L1
hole "Hole2" sketch "Sketch39" at (-26.137, -10.731) diameter "d192" = 3.175; stored, may be unused: countersink angle "d196" = 82 deg, drill point angle "d198" = 118 deg; dims "d193" = 12.7, "d194" = 9.525, "d195" = 6.35, "d197" = 19.05
sketch "Sketch40"
  geometry: L1 (-0.61, -15.145)-(-78.003, -15.145) reference; L2 (6.985, 0)-(6.985, -25.616) reference; L3 (-54.712, -4.762)-(-3.632, -4.762) reference; L4 (-78.003, -15.145)-(-78.003, -12.7) reference; L5 (-43.18, -10.466)-(-43.18, -15.145); L6 (-51.321, -15.145)-(-35.039, -15.145); L7 (-35.039, -15.145)-(-35.039, -19.926); L8 (-35.039, -19.926)-(-51.321, -19.926); L9 (-51.321, -19.926)-(-51.321, -15.145)
  constraints: 10 end point, 3 parallel, 1 horizontal, 1 midpoint, 1 perpendicular, 1 point on line
  dimensions: "d199" = 50.165 distance between parallel lines of L5 L2; "d200" = 8.1407 distance between parallel lines of L7 L5; "d201" = 8.1407 distance between parallel lines of L5 L9; "d202" = 15.1638 distance between parallel lines of L8 L3
extrude "Extrusion37" join sketch "Sketch40" stored distance "d203" = 3.175; taper "d204" = 0 deg
sketch "Sketch41"
  geometry: L1 (46.971, -36.779)-(46.971, -31.591) reference; L2 (23.146, -36.779)-(46.971, -36.779) reference; L3 (30.162, -50)-(45.403, -50) reference; L4 (89.181, -35.192)-(52.986, -35.192) reference; L5 (89.181, -25.317)-(89.181, -35.192) reference; L6 (88.877, -25.317)-(89.181, -25.317) reference; L7 (79.654, -16.732)-(79.654, -21.349) reference; L8 (7.595, -16.732)-(79.654, -16.732) reference; L9 (5.213, -27.329)-(5.213, -19.113) reference; L10 (5.213, -27.329)-(5.231, -27.329) reference; L11 (43.796, -30.004)-(7.595, -30.004) reference; L12 (42.024, -19.926)-(58.306, -19.926) reference; L13 (58.306, -19.926)-(58.306, -16.732) reference; L14 (42.024, -16.732)-(42.024, -19.926) reference; L15 (58.306, -19.926)-(42.024, -19.926); L16 (42.024, -19.926)-(42.024, -15.145); L17 (42.024, -15.145)-(58.306, -15.145); L18 (58.306, -15.145)-(58.306, -19.926); C1 r 3.969 at (37.363, -42.126) reference; A1 r 1.587 centre (24.727, -36.633) between (23.146, -36.779) and (23.659, -37.807) reference; A2 r 20.546 centre (9.838, -53.01) between (30.162, -50) and (23.659, -37.807) reference; A3 r 16.573 centre (61.952, -49.13) between (52.986, -35.192) and (45.403, -50) reference; A4 r 2.381 centre (7.595, -19.113) between (7.595, -16.732) and (5.213, -19.113) reference; A5 r 2.381 centre (7.595, -27.622) between (5.231, -27.329) and (7.595, -30.004) reference
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 2 other
extrude "Extrusion38" join sketch "Sketch41" stored distance "d205" = 3.175; taper "d206" = 0 deg
sketch "Sketch42"
  geometry: L1 (6.985, 0)-(6.985, -25.616) reference; L2 (-54.712, -4.762)-(-3.632, -4.762) reference; 1 further point
  dimensions: "d207" = 50.2158 distance from line of point (-43.231, -16.827) L1; "d208" = 12.065 distance from line of point (-43.231, -16.827) L2
hole "Hole3" sketch "Sketch42" at (-43.231, -16.827) diameter "d209" = 3.175; stored, may be unused: countersink angle "d213" = 82 deg, drill point angle "d215" = 118 deg; dims "d210" = 12.7, "d211" = 9.525, "d212" = 6.35, "d214" = 19.05
sketch "Sketch43"
  geometry: L1 (-52.146, 0)-(-74.371, 0) reference; L2 (-52.146, 0)-(-52.146, 24.409) reference; L3 (-74.371, 24.409)-(-52.146, 24.409) reference; L4 (-79.134, 19.647)-(-79.134, 4.763) reference; L5 (-71.412, 18.961)-(-2.083, 18.961); L6 (-2.083, 18.961)-(-2.083, 5.448); L7 (-2.083, 5.448)-(-71.412, 5.448); L8 (-71.412, 5.448)-(-71.412, 18.961); L9 (10.617, 24.409)-(10.617, 0) reference; L10 (-79.134, 12.205)-(-71.412, 12.205); L11 (-2.083, 12.205)-(10.617, 12.205); A1 r 4.763 centre (-74.371, 4.762) between (-79.134, 4.763) and (-74.371, 0) reference; A2 r 4.763 centre (-74.371, 19.647) between (-74.371, 24.409) and (-79.134, 19.647) reference
  constraints: 12 end point, 4 midpoint, 2 parallel, 1 horizontal, 1 perpendicular
  dimensions: "d216" = 12.7 distance between parallel lines of L9 L6; "d217" = 13.5128 distance of L7.end L5.start; "d220" = 7.7216 distance between parallel lines of L8 L4
extrude "Extrusion39" cut sketch "Sketch43" distance "d221" = 28.575; taper "d222" = 0 deg
sketch "Sketch44"
  geometry: L1 (-70.881, 23.749)-(-94.446, 23.749) reference; L2 (-53.875, 20.549)-(-53.875, 11.024); L3 (-98.706, 23.803)-(-98.706, 8.655); L4 (-77.015, 20.549)-(-53.875, 20.549); L5 (-53.875, 11.024)-(-77.015, 11.024); L6 (-77.015, 23.803)-(-77.015, 23.749); L7 (-77.015, 20.549)-(-77.015, 11.024); L8 (-98.706, 15.786)-(-77.015, 15.786); L9 (-53.875, 15.786)-(-47.139, 15.786); A1 r 9.525 centre (-89.181, 15.812) between (-89.181, 25.337) and (-98.706, 15.812) reference; A2 r 9.525 centre (-89.181, 15.786) between (-98.706, 15.786) and (-89.181, 6.261) reference
  constraints: 16 end point, 5 parallel, 2 midpoint, 2 tangent, 1 horizontal, 1 perpendicular, 1 point on line
  dimensions: "d224" = 44.831 distance between parallel lines of L2 L3
extrude "Extrusion40" cut sketch "Sketch44" stored distance "d228" = 31.75; taper "d229" = 0 deg
sketch "Sketch45"
  geometry: L1 (-70.881, -11.024)-(-70.881, -20.549) reference; L2 (-77.015, -11.024)-(-70.881, -11.024) reference; L3 (-77.015, -20.549)-(-77.015, -11.024) reference; L4 (-70.881, -20.549)-(-77.015, -20.549) reference
extrude "Extrusion41" cut sketch "Sketch45" distance "d230" = 6.35; taper "d231" = 0 deg
fillet "Fillet34" dims "d232" = 1.5875
fillet "Fillet35" dims "d233" = 1.5875
sketch "Sketch46"
  geometry: L1 (0, 0)-(2.425, 0) reference; L2 (0, 0)-(0, 6.35) reference; L3 (0, 6.375)-(0, 12.725) reference; L4 (2.425, 12.725)-(0, 12.725) reference; A1 r 9.525 centre (9.525, 6.35) between (0, 6.35) and (2.425, 0) reference; A2 r 9.525 centre (9.525, 6.375) between (2.425, 12.725) and (0, 6.375) reference
extrude "Extrusion42" cut sketch "Sketch46" stored distance "d234" = 6.35; taper "d235" = 0 deg
fillet "Fillet36" dims "d236" = 3.175
sketch "Sketch47"
  geometry: L1 (-19.037, 32.448)-(-15.583, 32.448); L2 (-19.037, 26.098)-(-19.037, 32.448); L3 (-15.583, 32.448)-(-15.583, 30.01); L4 (-15.583, 30.01)-(-19.037, 26.098)
  constraints: 8 end point, 1 horizontal, 1 parallel
extrude "Extrusion43" cut sketch "Sketch47" distance "d240" = 4.6736; taper "d241" = 0 deg
sketch "Sketch48"
  geometry: L1 (54.712, 4.762)-(51.079, 1.13) reference; L2 (56.558, 4.762)-(54.712, 4.762); L3 (54.712, 4.762)-(51.079, 1.13); L4 (51.079, 1.13)-(51.079, 0); L5 (56.558, 4.762)-(51.796, 0); L6 (51.079, 0)-(51.796, 0)
  constraints: 10 end point, 2 perpendicular, 1 collinear, 1 parallel
extrude "Extrusion44" cut sketch "Sketch48" stored distance "d242" = 4.6736; taper "d243" = 0 deg
fillet "Fillet37" dims "d244" = 3.175
fillet "Fillet38" dims "d245" = 0.79375
fillet "Fillet39" dims "d246" = 0.79375
fillet "Fillet40" dims "d247" = 0.79375
fillet "Fillet41" dims "d248" = 0.79375
fillet "Fillet42" dims "d249" = 0.79375
sketch "Sketch49"
  geometry: L1 (8.992, 10.49)-(8.992, 5.41) reference; L2 (19.037, 6.833)-(19.037, 32.448) reference; L3 (8.957, 32.448)-(8.992, 32.448); L4 (10.96, 32.448)-(10.96, 24.168); L5 (8.992, 26.622)-(8.957, 26.622); L6 (9.36, 32.448)-(9.36, 24.168); L7 (10.96, 32.448)-(9.36, 32.448); L8 (9.36, 24.168)-(10.96, 24.168)
  constraints: 12 end point, 2 parallel, 2 perpendicular, 2 point on line, 1 horizontal
  dimensions: "d250" = 8.0772 distance between parallel lines of L4 L2; "d252" = 1.6002 distance between parallel lines of L6 L4; "d253" = 8.2804 distance of L4.start L4.end; "d255" = 8.2804 distance of L6.start L6.end
extrude "Extrusion45" cut sketch "Sketch49" distance "d256" = 15.24; taper "d257" = 0 deg
sketch "Sketch50"
  geometry: L1 (-18.803, 30.429)-(34.115, 30.429) reference; L2 (42.894, 28.842)-(42.894, 9.576) reference; C1 r 2.381 at (24.003, 24.46) reference; 1 further point
  dimensions: "d259" = 23.1394 vertical distance of C1.centre point (23.844, 1.321); "d260" = 19.05 distance from line of L2 point (23.844, 1.321)
hole "Hole4" sketch "Sketch50" at (23.844, 1.321) diameter "d261" = 3.175; stored, may be unused: countersink angle "d265" = 82 deg, drill point angle "d267" = 118 deg; dims "d262" = 12.7, "d263" = 9.525, "d264" = 6.35, "d266" = 19.05
sketch "Sketch51"
  geometry: L1 (27.46, -3.6)-(24.725, -3.6) reference; L2 (42.894, -1.685)-(42.894, -3.6) reference; L3 (42.894, 4.736)-(42.894, -1.685) reference; L4 (28.513, -3.6)-(32.834, -3.6) reference; L5 (19.754, -5.041)-(19.754, -3.6) reference; L6 (28.924, -5.302)-(19.754, -5.302); L7 (19.754, -5.302)-(19.754, -3.6); L8 (-18.803, 26.829)-(34.115, 26.829) reference; L9 (19.754, -3.6)-(22.963, -3.6); L10 (28.924, -3.546)-(28.924, -2.648) reference; L11 (28.924, -3.546)-(28.924, -5.302); L12 (24.725, -3.6)-(28.924, -3.6); A1 r 1.588 centre (23.844, -2.28) between (22.963, -3.6) and (24.725, -3.6)
  constraints: 12 end point, 3 point on circle, 2 horizontal, 2 parallel, 1 centre point, 1 collinear, 1 horizontal alignment, 1 point on line
extrude "Extrusion46" join sketch "Sketch51" stored distance "d270" = 15.24; taper "d271" = 0 deg
sketch "Sketch52"
  geometry: L1 (3.782, -1.746)-(-0.552, -1.746) reference; L2 (-0.552, -3.6)-(-0.552, -1.746) reference; L3 (0.197, -3.6)-(-0.552, -3.6) reference; L4 (0.197, -3.6)-(0.197, -5.302) reference; L5 (0.197, -5.302)-(9.367, -5.302) reference; L6 (9.367, -5.302)-(9.367, -5.041) reference; L7 (9.367, -3.6)-(9.367, -5.041) reference; L8 (8.96, -3.6)-(9.367, -3.6) reference; L9 (8.96, -3.6)-(8.96, -1.746) reference; L10 (8.96, -1.746)-(6.773, -1.746) reference; L11 (9.367, -3.6)-(9.367, -5.302); L12 (9.367, -5.302)-(0.197, -5.302); L13 (0.197, -5.302)-(0.197, -3.6); L14 (0.197, -3.6)-(4.397, -3.6); L15 (6.158, -3.6)-(9.367, -3.6); A1 r 1.587 centre (5.277, -2.28) between (3.782, -1.746) and (6.773, -1.746) reference; A2 r 1.587 centre (5.277, -2.28) between (4.397, -3.6) and (6.158, -3.6)
  constraints: 10 end point, 3 parallel, 3 point on circle, 2 horizontal, 2 perpendicular, 1 centre point, 1 coincident, 1 concentric
extrude "Extrusion47" join sketch "Sketch52" stored distance "d272" = 15.24; taper "d273" = 0 deg
fillet "Fillet43" dims "d274" = 0.79375
fillet "Fillet44" dims "d275" = 0.79375
sketch "Sketch53"
  geometry: L1 (6.172, 1.702)-(6.172, 0.794) reference; L2 (2.343, 1.702)-(6.172, 1.702) reference; L3 (0, 0.261)-(1.921, 0.261) reference; L4 (0, 0)-(0, 0.261) reference; L5 (5.378, 0)-(0, 0) reference; A1 r 0.794 centre (5.378, 0.794) between (5.378, 0) and (6.172, 0.794) reference; A2 r 3.175 centre (5.093, 0.114) between (2.343, 1.702) and (1.921, 0.261) reference
extrude "Extrusion48" join sketch "Sketch53" distance "d276" = 25.4; taper "d277" = 0 deg
sketch "Sketch54"
  geometry: L1 (0, 2.667)-(0.473, 2.667) reference; L2 (0, 2.667)-(0, 0) reference; L3 (5.646, 0)-(0, 0) reference; A1 r 3.175 centre (5.646, 3.175) between (3.059, 1.334) and (5.646, 0) reference; A2 r 3.175 centre (0.473, -0.508) between (3.059, 1.334) and (0.473, 2.667) reference
extrude "Extrusion49" cut sketch "Sketch54" distance "d278" = 2.8575; taper "d279" = 0 deg
sketch "Sketch55"
  geometry: L1 (4.251, 0.261)-(6.172, 0.261) reference; L2 (0, 1.702)-(3.829, 1.702) reference; L3 (0, 0)-(0, 1.702) reference; L4 (0, 0)-(6.172, 0) reference; L5 (6.172, 0.261)-(6.172, 0) reference; A1 r 3.175 centre (1.079, 0.114) between (4.251, 0.261) and (3.829, 1.702) reference
extrude "Extrusion50" join sketch "Sketch55" distance "d280" = 25.4; taper "d281" = 0 deg
sketch "Sketch56"
  geometry: L1 (6.741, 0)-(0, 0) reference; L2 (0, 0)-(0, -2.667) reference; L3 (1.568, -2.667)-(0, -2.667) reference; A1 r 3.175 centre (6.741, -3.175) between (6.741, 0) and (4.154, -1.333) reference; A2 r 3.175 centre (1.568, 0.508) between (1.568, -2.667) and (4.154, -1.333) reference
extrude "Extrusion51" cut sketch "Sketch56" distance "d282" = 2.8575; taper "d283" = 0 deg
fillet "Fillet45" dims "d284" = 3.175
fillet "Fillet46" dims "d285" = 3.175
sketch "Sketch57"
  geometry: L1 (-7.969, -1.702)-(0.428, -1.702) reference; L2 (0.406, 0)-(0.406, -1.441) reference; L3 (0, 0)-(0.406, 0) reference; L4 (0, 0)-(0, 1.854) reference; L5 (0, 1.854)-(-2.188, 1.854) reference; L6 (-5.178, 1.854)-(-9.512, 1.854) reference; L7 (-9.512, 0)-(-9.512, 1.854) reference; L8 (-8.763, 0)-(-9.512, 0) reference; L9 (-8.763, 0)-(-8.763, -0.908) reference; L10 (-5.95, -1.702)-(19.066, -1.702) reference; L11 (19.066, 3.6)-(19.066, -1.702) reference; L12 (-8.96, 3.6)-(19.066, 3.6) reference; L13 (-8.96, -0.256)-(-8.96, 3.6) reference; C1 r 1.587 at (-3.683, 1.321) reference; A1 r 0.794 centre (-7.969, -0.908) between (-8.763, -0.908) and (-7.969, -1.702) reference; A2 r 1.587 centre (1.994, -1.441) between (0.406, -1.441) and (0.428, -1.702) reference; A3 r 1.587 centre (-3.683, 1.321) between (-5.178, 1.854) and (-2.188, 1.854) reference; A4 r 3.175 centre (-5.95, 1.473) between (-8.145, -0.821) and (-5.95, -1.702) reference
  constraints: 1 other
extrude "Extrusion52" join sketch "Sketch57" stored distance "d286" = 2.8575; taper "d287" = 0 deg
sketch "Sketch58"
  geometry: L1 (-7.969, -1.702)-(0.428, -1.702) reference; L2 (-8.763, 0)-(-8.763, -0.908) reference; L3 (-5.95, -1.702)-(-7.969, -1.702); L4 (-8.763, -0.36)-(-8.763, -0.908); L5 (-8.763, -0.36)-(-8.763, -0.908); A1 r 0.794 centre (-7.969, -0.908) between (-8.763, -0.908) and (-7.969, -1.702) reference; A2 r 3.175 centre (-5.95, 1.473) between (-8.145, -0.821) and (-5.95, -1.702) reference; 3 further points
  constraints: 6 end point, 2 collinear, 2 tangent, 1 point on circle, 1 point on line, 3 other
extrude "Extrusion53" cut sketch "Sketch58" stored distance "d288" = 2.8575; taper "d289" = 0 deg
sketch "Sketch59"
  geometry: L1 (-8.763, 0)-(-8.763, -0.36) reference; L2 (-8.763, 0)-(-8.763, -0.36); L3 (-8.763, 0)-(-9.718, 0); 3 further points
  constraints: 4 end point, 1 collinear, 1 perpendicular, 3 other
extrude "Extrusion54" join sketch "Sketch59" stored distance "d290" = 2.8575; taper "d291" = 0 deg
fillet "Fillet47" dims "d292" = 0.79375
sketch "Sketch60"
  geometry: L1 (19.754, -4.509)-(0, -4.509); L2 (0, -4.509)-(0, -5.302); L3 (0, -5.302)-(19.754, -5.302); L4 (19.754, -5.302)-(19.754, -4.509)
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular
extrude "Extrusion55" join sketch "Sketch60" stored distance "d293" = 2.8575; taper "d294" = 0 deg
sketch "Sketch61"
  geometry: L1 (0, 19.266)-(0, 0) reference; L2 (-61.697, 20.853)-(-8.778, 20.853) reference; 1 further point
  dimensions: "d295" = 58.9534 distance from line of point (-58.953, -5.055) L1; "d296" = 25.908 distance from line of point (-58.953, -5.055) L2
hole "Hole5" sketch "Sketch61" at (-58.953, -5.055) diameter "d297" = 2.4384; stored, may be unused: countersink angle "d301" = 82 deg, drill point angle "d303" = 118 deg; dims "d298" = 12.7, "d299" = 9.525, "d300" = 6.35, "d302" = 19.05
sketch "Sketch62"
  geometry: L1 (-25.009, -11.278)-(-48.067, -11.278) reference; L2 (-43.713, 5.295)-(-43.713, -1.994); L3 (0, 19.266)-(0, 0) reference; L4 (-58.306, 5.69)-(-42.024, 5.69) reference; C1 r 3.175 at (-46.888, 2.515)
  constraints: 2 end point, 2 tangent, 1 centre point, 1 perpendicular
  dimensions: "d304" = 43.7134 distance between parallel lines of L2 L3; "d305" = 6.35 diameter of C1
extrude "Extrusion56" cut sketch "Sketch62" stored distance "d306" = 2.8575; taper "d307" = 0 deg
sketch "Sketch63"
  geometry: L1 (-52.411, -39.873)-(-70.881, -39.873) reference; A1 r 3.175 centre (-52.411, -36.698) between (-52.411, -39.873) and (-50.589, -39.298) reference; A2 r 19.736 centre (-61.916, -23.137) between (-50.589, -39.298) and (-42.552, -26.946) reference; A3 r 6.472 centre (-53.55, -33.453) between (-52.733, -39.873) and (-49.951, -38.832)
  constraints: 3 point on circle, 1 centre point, 1 point on line
extrude "Extrusion57" cut sketch "Sketch63" stored distance "d308" = 2.8575; taper "d309" = 0 deg
sketch "Sketch64"
  geometry: L1 (13.027, 16.624)-(13.027, 7.785) reference; L2 (13.027, 16.624)-(13.177, 16.624) reference; L3 (35.358, 16.624)-(13.177, 16.624) reference; L4 (13.182, 7.785)-(35.359, 7.785) reference; L5 (13.027, 7.785)-(13.182, 7.785) reference; L6 (15.421, 16.624)-(15.421, 7.785); L7 (28.575, 5.448)-(9.309, 5.448) reference; L8 (9.309, 18.961)-(28.575, 18.961) reference; L9 (15.421, 5.448)-(9.309, 5.448); L10 (9.309, 5.448)-(9.309, 18.961); L11 (9.309, 18.961)-(15.421, 18.961); L12 (15.421, 18.961)-(15.421, 5.448); 1 further point
  constraints: 10 end point, 5 point on line, 2 parallel, 1 horizontal, 1 perpendicular
extrude "Extrusion58" cut sketch "Sketch64" distance "d310" = 38.1; taper "d311" = 0 deg
sketch "Sketch65"
  geometry: L1 (0, 2.824)-(2.007, 2.824) reference; L2 (0, 0)-(0, 2.824) reference; L3 (1.738, 0)-(0, 0) reference; L4 (2.007, 2.824)-(2.007, 0.429) reference; A1 r 1.587 centre (3.2, -0.618) between (2.007, 0.429) and (1.738, 0) reference; 1 further point
extrude "Extrusion59" join sketch "Sketch65" stored distance "d312" = 38.1; taper "d313" = 0 deg
sketch "Sketch66"
  geometry: L1 (-1.981, 2.824)-(0, 2.824) reference; L2 (-1.981, 2.824)-(-1.981, 0.429) reference; L3 (0, 0)-(-1.713, 0) reference; L4 (0, 2.824)-(0, 0) reference; A1 r 1.587 centre (-3.175, -0.618) between (-1.713, 0) and (-1.981, 0.429) reference; 1 further point
extrude "Extrusion60" join sketch "Sketch66" stored distance "d314" = 38.1; taper "d315" = 0 deg
fillet "Fillet48" dims "d316" = 3.175
fillet "Fillet49" dims "d317" = 3.175
fillet "Fillet50" dims "d318" = 3.175
sketch "Sketch67"
  geometry: L1 (89.181, -9.576)-(52.986, -9.576) reference; L2 (53.472, -36.698)-(70.881, -36.698) reference; L3 (42.186, -25.971)-(45.6, -25.971) reference; L4 (70.881, -39.873)-(52.733, -39.873) reference; L5 (87.521, -19.004)-(87.615, -22.845) reference; L6 (80.736, -11.163)-(92.917, -11.163) reference; L7 (82.029, -13.721)-(82.029, -14.48) reference; L8 (72.242, -9.576)-(71.607, -9.576); L9 (71.607, -9.576)-(71.607, -11.632); L10 (80.736, -11.163)-(71.607, -11.632); A1 r 3.175 centre (85.204, -14.48) between (82.029, -14.48) and (82.487, -16.122) reference; A2 r 13.561 centre (70.881, -23.137) between (70.881, -36.698) and (82.487, -16.122) reference; A3 r 3.175 centre (53.472, -33.523) between (51.469, -35.987) and (53.472, -36.698) reference; A4 r 16.561 centre (61.916, -23.137) between (45.6, -25.971) and (51.469, -35.987) reference; A5 r 3.175 centre (39.436, -27.559) between (42.552, -26.946) and (42.186, -25.971) reference; A6 r 19.736 centre (61.916, -23.137) between (42.552, -26.946) and (49.951, -38.832) reference; A7 r 6.472 centre (53.55, -33.453) between (49.951, -38.832) and (52.733, -39.873) reference; A8 r 16.736 centre (70.881, -23.137) between (70.881, -39.873) and (87.615, -22.845) reference; A9 r 11.349 centre (98.706, -20.925) between (92.917, -11.163) and (87.521, -19.004) reference; A10 r 3.175 centre (78.854, -13.721) between (82.029, -13.721) and (80.736, -11.163) reference; A11 r 23.516 centre (72.242, -33.092) between (80.736, -11.163) and (72.242, -9.576); 1 further point
  constraints: 6 end point, 2 point on circle, 2 point on line, 2 tangent, 1 centre point, 1 perpendicular
extrude "Extrusion61" cut sketch "Sketch67" stored distance "d319" = 38.1; taper "d320" = 0 deg
sketch "Sketch68"
  geometry: L1 (82.029, -13.721)-(82.029, -14.48) reference; L2 (82.029, -14.244)-(82.064, -14.949); A1 r 7.252 centre (75.014, -16.652) between (82.064, -14.949) and (78.929, -10.547); A2 r 3.193 centre (78.877, -13.739) between (82.029, -14.244) and (78.929, -10.547); 2 further points
  constraints: 4 point on circle, 2 centre point, 2 end point, 1 point on line, 1 other
extrude "Extrusion62" join sketch "Sketch68" stored distance "d321" = 38.1; taper "d322" = 0 deg
sketch "Sketch69"
  geometry: L1 (-82.029, -14.48)-(-82.029, -13.721) reference; A1 r 3.175 centre (-85.204, -14.48) between (-82.487, -16.122) and (-82.029, -14.48) reference; A2 r 3.175 centre (-78.854, -13.721) between (-80.736, -11.163) and (-82.029, -13.721) reference; A3 r 7.252 centre (-75.014, -16.652) between (-78.929, -10.547) and (-82.064, -14.949) reference; 1 further point
  constraints: 1 other
extrude "Extrusion63" join sketch "Sketch69" stored distance "d323" = 38.1; taper "d324" = 0 deg
fillet "Fillet51" dims "d325" = 3.175
sketch "Sketch70"
  geometry: L1 (-53.875, 20.549)-(-53.875, 11.024) reference; L2 (-53.875, 11.024)-(-53.875, 20.549); L3 (-53.875, 20.549)-(-52.986, 20.549); L4 (-53.875, 11.024)-(-52.986, 11.024); L5 (-52.986, 20.549)-(-52.986, 11.024); 1 further point
  constraints: 8 end point, 2 perpendicular
extrude "Extrusion64" cut sketch "Sketch70" stored distance "d326" = 38.1; taper "d327" = 0 deg
fillet "Fillet52" dims "d328" = 3.175
sketch "Sketch71"
  geometry: L1 (80.736, -11.163)-(79.755, -11.163); A1 r 3.175 centre (78.854, -13.721) between (80.736, -11.163) and (78.819, -10.546) reference; A2 r 3.175 centre (77.544, -13.454) between (79.514, -10.964) and (78.819, -10.546) reference; A3 r 7.252 centre (75.014, -16.652) between (82.064, -14.949) and (79.514, -10.964) reference; 1 further point
  constraints: 2 end point, 1 point on circle
extrude "Extrusion65" join sketch "Sketch71" stored distance "d330" = 38.1; taper "d331" = 0 deg
sketch "Sketch72"
  geometry: L1 (-80.736, -11.163)-(-79.755, -11.163); A1 r 7.252 centre (-75.014, -16.652) between (-79.514, -10.964) and (-82.064, -14.949) reference; A2 r 3.175 centre (-77.544, -13.454) between (-78.819, -10.546) and (-79.514, -10.964) reference; A3 r 3.175 centre (-78.854, -13.721) between (-78.819, -10.546) and (-80.736, -11.163) reference; 1 further point
  constraints: 2 end point, 1 point on circle
extrude "Extrusion66" join sketch "Sketch72" stored distance "d332" = 38.1; taper "d333" = 0 deg
sketch "Sketch73"
  geometry: L1 (-9.928, 18.961)-(-71.412, 18.961) reference; L2 (-71.412, 5.448)-(-42.369, 5.448); L3 (-42.369, 5.448)-(-42.369, 18.961); L4 (-42.369, 18.961)-(-71.412, 18.961); L5 (-71.412, 18.961)-(-71.412, 5.448); 1 further point
  constraints: 8 end point, 2 parallel, 1 horizontal, 1 perpendicular, 1 point on line
extrude "Extrusion67" cut sketch "Sketch73" distance "d334" = 12.7; taper "d335" = 0 deg
body "Solid1"
node "Projected Loop2"
node "Projected Loop3"
node "Projected Loop4"
node "Projected Loop5"
node "Projected Loop6"
node "Projected Loop7"
node "Reference5"
node "Reference6"
node "Reference7"
node "Reference8"
node "Reference9"
node "Projected Loop8"
other parameters: "d73" = 90 deg, "d96" = 6.0325, "d97" = 6.0325, "d152" = 2.159, "d157" = 14.8082 (derived), "d174" = 3.175, "d218" = 6.7564, "d219" = 6.7564 (derived), "d225" = 23.1394, "d226" = 4.7625, "d227" = 4.7625
